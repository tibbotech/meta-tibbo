DESCRIPTION = "TPS www user"
HOMEPAGE = "http://tibbo.com/"
MAINTAINER = "Dmitry Dvorkin <dvorkin@tibbo.com>"
LICENSE = "GPL-3.0-or-later"
SECTION = "base"

inherit useradd

require tps-www-user.inc
