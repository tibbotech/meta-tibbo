
require tps-pinsini.inc

DESCRIPTION = "TPPgX pins.ini shared base definition"
