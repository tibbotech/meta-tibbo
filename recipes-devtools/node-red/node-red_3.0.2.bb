
require node-red.inc

SRC_URI[pkg.sha256sum] = "6c452646648f9e86622148eff2208fb45d2311b5339481f86b445e9e2fa215c5"
