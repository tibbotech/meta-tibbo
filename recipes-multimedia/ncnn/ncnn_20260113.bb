require ncnn.inc

SRCREV = "e956fbf9bd97fe945df35d736747dc816f8b5f42"

SRC_URI = "git://github.com/Tencent/ncnn.git;protocol=https;branch=master"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=d2141d1a2c978a089d3de7a67db0bbd2"
