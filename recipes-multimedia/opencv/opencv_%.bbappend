
PACKAGECONFIG += "dnn"
PACKAGECONFIG += "python3"

EXTRA_OECMAKE += "-DENABLE_NEON=ON"
