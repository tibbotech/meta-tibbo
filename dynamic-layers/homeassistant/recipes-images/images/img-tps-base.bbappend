
IMAGE_INSTALL += "python3-homeassistant python3-appdaemon"
