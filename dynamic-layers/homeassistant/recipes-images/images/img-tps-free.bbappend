
IMAGE_INSTALL += "python3-homeassistant"
